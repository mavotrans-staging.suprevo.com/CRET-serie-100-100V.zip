Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-04-06T08:18:42
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Apr 06 08:18:42 2023 * Host: MAV-DTP-TESSA * Database: C:\Users\T6FAF~1.PLA\AppData\Local\Temp\fdaae377-05c3-4360-8a65-4f585b0c56b6\d633e124-6d93-4611-8dce-b87aba191ab9\ifc * Database version: 5507 * Database creation date: Thu Apr 06 08:18:42 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Apr 06 08:18:42 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Apr 06 08:18:42 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Other - BCB_ProjectFolder: C:\Users\t.plat\OneDrive - Mavotrans\BIM T&D\3. Modellen Mavotrans\1. Betonkoppelsystemen\10-Dwarskrachtdeuvels; Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; BCB_ProjectFolder: C:\Users\t.plat\OneDrive - Mavotrans\BIM T&D\3. Modellen Mavotrans\1. Betonkoppelsystemen\10-Dwarskrachtdeuvels; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Circle Head - Project Datum
Pset_AirSideSystemInformation - Name: Level 0
Pset_ProductRequirements - Name: Level 0; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 0; Structural: no
Other - Category: Levels; Family: Level: Circle Head - Project Datum; Family and Type: Level: Circle Head - Project Datum; Type: Level: Circle Head - Project Datum; Type Id: Level: Circle Head - Project Datum
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle: Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no

# IfcBuildingElementProxy: 102145, NLRSnl_28_GM_102-CRET-Serie-100_R20:102145_CRET-145:331318
In: Level 0
Type - Description: CRET-145; Material: Mavotrans - stainless steel, Corrossiebestendigheidsklasse 2, Corrosion resistance class 2
Type - Constraints - Default Elevation: 200 mm
Type - Construction - h_d: 50 mm; h_h: 50 mm; h_l_eff: 302 mm; h_t: 2 mm; h_w: 50 mm; l_h: 250 mm; l_h1: 270 mm; l_h3: 170 mm; l_l: 210 mm; l_l_screw1: 30 mm; l_l_screw2: 180 mm; l_l1: 34 mm; l_l2: 200 mm; l_r: 10 mm; l_t: 5 mm; ld_w: 124 mm; ld_w_screw: 69 mm; lh_w_screw: 74 mm; s_d: 20 mm
Type - Dimensions - Diameter Ø: 45 mm; Dowel length: 546 mm; Dowel width: 124 mm; Height: 380 mm; Sleeve length: 309 mm; Sleeve width: 154 mm
Type - Graphics - CRET-dowel_rectangular: yes; CRET-dowel_round: no; CRET-sleeves_rectangular: yes; CRET-sleeves_round: no
Type - Identity Data - Artikelnummer | Article number: 102145; Beschrijving | Description: CRET-145; Laatste versie | Last version: 31-03-2023; Leverancier | Supplier: Mavotrans; NL-SfB code: 28; OmniClass Number: 23.25.10.27.11; OmniClass Title: Reinforcement Components; Opmerkingen | Comments: Dwarskrachtdeuvel | Shear load connector; Revisie | Revision: Rev0; Technische data | Technical data: Raadpleeg de gekoppelde webpagina | Please refer to linked URL; Tekenaar | Draftsman: T. Plat; Type Name: 102145_CRET-145; URL: https://mavotrans.nl/cret-100-serie.html; Voorwaarden | Disclaimer: Raadpleeg de gekoppelde webpagina en controleer voor gebruik van dit BIM-model op de laatst beschikbare revisie. De modellen, geometrie, data en parameterwaarden zijn met de grootste zorg bepaald. Desalniettemin bestaat de mogelijkheid op onjuistheden. Elke aansprakelijkheid hiervoor wordt van de hand gewezen, hoewel melding op prijs wordt gesteld. © Mavotrans, 2022 | Please refer to linked URL and check for the latest available model revision. The models, geometry and parameter values have been determined with the greatest care. Still, they are subject to errors. Mavotrans cannot be held liable in any way. However, we do appreciate your feedback. © Mavotrans, 2022; Zijdelingse verplaatsing / Lateral displacement +/-: 0 mm
Type - Materials and Finishes - Dowel_material: Corrossiebestendigheidsklasse 2, Corrosion resistance class 2; Material: Corrossiebestendigheidsklasse 2, Corrosion resistance class 2
Type - Other - Category: Generic Models; Family Name: NLRSnl_28_GM_102-CRET-Serie-100_R20
Type - Pset_BuildingElementProxyCommon - Reference: NLRSnl_28_GM_102-CRET-Serie-100_R20:102145_CRET-145
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: NLRSnl_28_GM_102-CRET-Serie-100_R20:102145_CRET-145
Pset_BuildingElementProxyCommon - sets with these values: 2
Constraints - Elevation from Level: 0 mm; Host: Level : Level 0; Level: Level: Level 0; Schedule Level: Level: Level 0
Construction - bm_distance: 20 mm
Dimensions - Area: 0.547281 m2; e_accepted: 20 mm; e Voeg / joint: 20 mm; Volume: 0.00242242 m3
Graphics - warning: no
Other - Family: NLRSnl_28_GM_102-CRET-Serie-100_R20: 102145_CRET-145; Family and Type: NLRSnl_28_GM_102-CRET-Serie-100_R20: 102145_CRET-145; Type: NLRSnl_28_GM_102-CRET-Serie-100_R20: 102145_CRET-145; Type Id: NLRSnl_28_GM_102-CRET-Serie-100_R20: 102145_CRET-145
Phasing - Phase Created: New Construction
